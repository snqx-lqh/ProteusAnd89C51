# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\software\Program\Keil5\C51\INC;src
  group SRC
    ./: LCD1602.c main.c ADC0832.c
